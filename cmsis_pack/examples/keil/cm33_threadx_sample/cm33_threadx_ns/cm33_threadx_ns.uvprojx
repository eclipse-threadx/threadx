# Keil uVision project cm33_threadx_ns.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: ARMCM33_DSP_FP_TZ ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: cm33_threadx_ns
  c flags: Optim=3 uC99=1 uGnu=1 v6Lang=3 v6LangP=1
  c misc: -Wno-unused-function -Wno-visibility
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\RTE\Device\ARMCM33_DSP_FP_TZ\ARMCM33_ac6.sct
  group Source Group 1
    ./: demo_threadx.c
  group cmse lib
    ../cm33_threadx_s/Objects/: cm33_threadx_s_CMSE_Lib.o
software components: CMSIS:CORE 5.6.0, Device:Startup 2.1.0, RTOS:ThreadX:Core 6.2.0
