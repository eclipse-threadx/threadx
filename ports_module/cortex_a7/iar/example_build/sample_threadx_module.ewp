# IAR project sample_threadx_module.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 52
  General.FPU2: 5
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\common\inc; ..\..\..\..\common_modules\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: THUMB_MODE
  OBJCOPY.OOCOutputFile: sample_threadx_module.bin
  ILINK.IlinkOutputFile: sample_threadx_module.out
  ILINK.IlinkIcfFile: sample_threadx_module.icf
  ILINK.IlinkProgramEntryLabel: _txm_module_thread_shell_entry
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  group (top)
    ./: sample_threadx_module.c txm_module_preamble.s
    Debug/Exe/: txm.a
