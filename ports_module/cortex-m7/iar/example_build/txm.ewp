# IAR project txm.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 0
  ICCARM.CCIncludePath2: ../inc; ../../../../common/inc; ../../../../common_modules/inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: txm.out
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group inc
    ../../../../common/inc/: tx_api.h tx_block_pool.h tx_byte_pool.h tx_event_flags.h tx_initialize.h tx_mutex.h tx_queue.h tx_semaphore.h tx_thread.h tx_timer.h tx_trace.h tx_user_sample.h
    ../module_common/inc/: tx_port.h txm_module_port.h
    ../../../../common_modules/: txm_module.h
    ../../../../common_modules/module_common/inc/: txm_module_user.h
  group src
    ../../../../common_modules/module_lib/src/: txm_block_allocate.c txm_block_pool_create.c txm_block_pool_delete.c txm_block_pool_info_get.c txm_block_pool_performance_info_get.c txm_block_pool_performance_system_info_get.c txm_block_pool_prioritize.c txm_block_release.c txm_byte_allocate.c txm_byte_pool_create.c txm_byte_pool_delete.c txm_byte_pool_info_get.c txm_byte_pool_performance_info_get.c txm_byte_pool_performance_system_info_get.c txm_byte_pool_prioritize.c txm_byte_release.c txm_event_flags_create.c txm_event_flags_delete.c txm_event_flags_get.c txm_event_flags_info_get.c txm_event_flags_performance_info_get.c txm_event_flags_performance_system_info_get.c txm_event_flags_set.c txm_event_flags_set_notify.c txm_module_application_request.c txm_module_callback_request_thread_entry.c txm_module_object_allocate.c txm_module_object_deallocate.c txm_module_object_pointer_get.c txm_module_object_pointer_get_extended.c txm_module_thread_system_suspend.c txm_mutex_create.c txm_mutex_delete.c txm_mutex_get.c txm_mutex_info_get.c txm_mutex_performance_info_get.c txm_mutex_performance_system_info_get.c txm_mutex_prioritize.c txm_mutex_put.c txm_queue_create.c txm_queue_delete.c txm_queue_flush.c txm_queue_front_send.c txm_queue_info_get.c txm_queue_performance_info_get.c txm_queue_performance_system_info_get.c txm_queue_prioritize.c txm_queue_receive.c txm_queue_send.c txm_queue_send_notify.c txm_semaphore_ceiling_put.c txm_semaphore_create.c txm_semaphore_delete.c txm_semaphore_get.c txm_semaphore_info_get.c txm_semaphore_performance_info_get.c txm_semaphore_performance_system_info_get.c txm_semaphore_prioritize.c txm_semaphore_put.c txm_semaphore_put_notify.c txm_thread_create.c txm_thread_delete.c txm_thread_entry_exit_notify.c txm_thread_identify.c txm_thread_info_get.c txm_thread_interrupt_control.c txm_thread_performance_info_get.c txm_thread_performance_system_info_get.c txm_thread_preemption_change.c txm_thread_priority_change.c txm_thread_relinquish.c txm_thread_reset.c txm_thread_resume.c txm_thread_sleep.c txm_thread_stack_error_notify.c txm_thread_suspend.c txm_thread_terminate.c txm_thread_time_slice_change.c txm_thread_wait_abort.c txm_time_get.c txm_time_set.c txm_timer_activate.c txm_timer_change.c txm_timer_create.c txm_timer_deactivate.c txm_timer_delete.c txm_timer_info_get.c txm_timer_performance_info_get.c txm_timer_performance_system_info_get.c txm_trace_buffer_full_notify.c txm_trace_disable.c txm_trace_enable.c txm_trace_event_filter.c txm_trace_event_unfilter.c txm_trace_interrupt_control.c txm_trace_isr_enter_insert.c txm_trace_isr_exit_insert.c txm_trace_user_event_insert.c
    ../module_lib/src/: txm_module_thread_shell_entry.c
