# IAR project sample_threadx.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCIncludePath2: ../inc; ../module_manager/inc; ../../../../common/inc; ../../../../modules/module_common/inc; ../../../../modules/module_manager/inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: sample_threadx.srec
  ILINK.IlinkOutputFile: sample_threadx.out
  ILINK.IlinkIcfFile: sample_threadx.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: dl-stnl0.a
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: cstartup_M.s sample_threadx.c tx_initialize_low_level.s
    Debug/Exe/: tx.a
