# IAR project sample_threadx_module_manager.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746IG ST STM32F746IG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCIncludePath2: ../inc; ../module_manager/inc; ../../../../common/inc; ..\..\..\..\common_modules\inc; ..\..\..\..\common_modules\module_manager\inc; ./libraries/libchip_samv7/include/cmsis/CMSIS/Include; ./libraries/libchip_samv7; ./libraries/libchip_samv7/include; ./libraries/libboard_samv7-ek; ./libraries/libboard_samv7-ek/include; ./libraries/
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: sample_threadx_module_manager_stm32f4xx.srec
  ILINK.IlinkOutputFile: sample_threadx_module_manager_stm32f4xx.out
  ILINK.IlinkIcfFile: sample_threadx_module_manager.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: sample_threadx_module_manager.c startup.s tx_initialize_low_level.s
    Debug/Exe/: tx.a
