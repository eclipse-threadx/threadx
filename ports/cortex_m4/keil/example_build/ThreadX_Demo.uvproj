# Keil uVision project ThreadX_Demo.uvproj, settings and files
target ThreadX_Demo (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: threadx_demo
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: ../inc;../../../../common/inc
  link misc: --first __tx_vectors --entry=__main
  group Source Group
    ./: tx_initialize_low_level.s demo_threadx.c
  group Library_Group
    ./: ThreadX_Library.lib
