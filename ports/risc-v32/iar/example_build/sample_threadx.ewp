# IAR project sample_threadx.ewp, settings and files
configuration Debug (RISCV, debug)
  General.GDeviceSelect: RV32IAF RV32IAF
  General.GHeapSize: 0x1000
  ICCRISCV.IccLang: 0
  ICCRISCV.CCOptLevel: 1
  ICCRISCV.CCOptStrategy: 0
  ICCRISCV.CCIncludePath2: ; ..\inc; ..\..\..\..\common\inc
  OBJCOPY.OOCOutputFile: sample_threadx.srec
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkOutputFile: sample_threadx.out
  ILINK.IlinkIcfFile: sample_threadx.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  ILINK.IlinkExtraOptions: --auto_vector_setup
configuration Release (RISCV)
  as the first configuration, except:
  ICCRISCV.CCOptLevel: 3
  ICCRISCV.CCDefines: NDEBUG
  group (top)
    ./: sample_threadx.c
    Debug/Exe/: tx.a
