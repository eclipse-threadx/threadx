# Keil uVision project demo_threadx_non-secure_zone.uvprojx, settings and files
target FVP Simulation Model (6180000::V6.18::ARMCLANG)
  device: SSE-300-MPS3 ARM
  pack: ARM.V2M_MPS3_SSE_300_BSP.1.3.0
  cpu: IRAM(0x00000000,0x00080000) IRAM2(0x01000000,0x00200000) XRAM(0x20000000,0x00020000) XRAM2(0x20020000,0x00020000) XRAM3(0x20040000,0x00020000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: demo_threadx_non-secure_zone
  c flags: Optim=2 v6Lang=3 v6LangP=1 wLevel=3
  c include: ..\..\..\..\..\common\inc, ..\..\inc
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT7: RAM 0x20020000 size 0x20000
  memory RVCT8: RAM 0x20040000 size 0x20000
  memory RVCT9: RAM 0x0 size 0x80000
  memory RVCT10: RAM 0x1000000 size 0x200000
  scatter file: ..\CS300_ac6.sct
  group Non-secure Code
    ./: demo_threadx.c
    ../: ThreadX_Library.lib
  group CMSE Library
    ../demo_secure_zone/: interface.h
    ../demo_secure_zone/Objects/: demo_secure_zone_CMSE_Lib.o
software components: CMSIS:CORE 5.6.0, Device:Definition 1.2.0, Device:Startup 1.2.0, Native Driver:SysCounter 1.1.0, Native Driver:SysTimer 1.1.0, Native Driver:Timeout 1.0.0
